<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>COLDFIRE</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>C-SPY</name>
      <archiveVersion>3</archiveVersion>
      <data>
        <version>1</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>CMandatory</name>
          <state>1</state>
        </option>
        <option>
          <name>CInput</name>
          <state>1</state>
        </option>
        <option>
          <name>DebuggerProcessorVariant</name>
          <state>0</state>
        </option>
        <option>
          <name>DebuggerNoDiv</name>
          <state>0</state>
        </option>
        <option>
          <name>DebuggerFPUnit</name>
          <state>0</state>
        </option>
        <option>
          <name>DebuggerMacMode</name>
          <state>0</state>
        </option>
        <option>
          <name>DebuggerPheripheral</name>
          <state>0</state>
        </option>
        <option>
          <name>CRunToEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>CRunToName</name>
          <state>main</state>
        </option>
        <option>
          <name>CMacOverride</name>
          <state>0</state>
        </option>
        <option>
          <name>CMacFile</name>
          <state></state>
        </option>
        <option>
          <name>DynDriver</name>
          <state>BDMCF</state>
        </option>
        <option>
          <name>DDFOverride</name>
          <state>0</state>
        </option>
        <option>
          <name>DDFFile</name>
          <state>$TOOLKIT_DIR$\CONFIG\DDF\iom5282.ddf</state>
        </option>
        <option>
          <name>DebugUseExtraOptions</name>
          <state>0</state>
        </option>
        <option>
          <name>DebugExtraOptions</name>
          <state></state>
        </option>
        <option>
          <name>FlashLoaders</name>
          <state>,,,,$PROJ_DIR$\FlashV2Internal_Loader.d68,--cpu_freq 75000</state>
        </option>
        <option>
          <name>UseFlashLoader</name>
          <state>1</state>
        </option>
        <option>
          <name>SuppressDownload</name>
          <state>0</state>
        </option>
        <option>
          <name>VerifyAll</name>
          <state>0</state>
        </option>
        <option>
          <name>OCImagesSuppressCheck1</name>
          <state>0</state>
        </option>
        <option>
          <name>OCImagesPath1</name>
          <state></state>
        </option>
        <option>
          <name>OCImagesSuppressCheck2</name>
          <state>0</state>
        </option>
        <option>
          <name>OCImagesPath2</name>
          <state></state>
        </option>
        <option>
          <name>OCImagesSuppressCheck3</name>
          <state>0</state>
        </option>
        <option>
          <name>OCImagesPath3</name>
          <state></state>
        </option>
      </data>
    </settings>
    <settings>
      <name>BDMCF</name>
      <archiveVersion>3</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>BdmMandatory</name>
          <state>1</state>
        </option>
        <option>
          <name>MemoryRanges</name>
          <state>1</state>
        </option>
        <option>
          <name>CommunicationPort</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>CommunicationType</name>
          <version>0</version>
          <state>3</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>JLINKCF</name>
      <archiveVersion>3</archiveVersion>
      <data>
        <version>1</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>JlinkMandatory</name>
          <state>1</state>
        </option>
        <option>
          <name>JLinkEnablePower</name>
          <state>0</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>SIMCF</name>
      <archiveVersion>3</archiveVersion>
      <data>
        <version>1</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>SimExceptions</name>
          <state>0</state>
        </option>
        <option>
          <name>SimMandatory</name>
          <state>1</state>
        </option>
        <option>
          <name>SimEnablePSP</name>
          <state>0</state>
        </option>
        <option>
          <name>SimPspOverrideConfig</name>
          <state>0</state>
        </option>
        <option>
          <name>SimPspConfigFile</name>
          <state>$TOOLKIT_DIR$\CONFIG\iocf.psp.config</state>
        </option>
      </data>
    </settings>
    <debuggerPlugins>
      <plugin>
        <file>$TOOLKIT_DIR$\plugins\rtos\embOS\embOSPlugin.ewplugin</file>
        <loadFlag>0</loadFlag>
      </plugin>
      <plugin>
        <file>$TOOLKIT_DIR$\plugins\rtos\MQX\MQXRtosPlugin.ewplugin</file>
        <loadFlag>0</loadFlag>
      </plugin>
      <plugin>
        <file>$TOOLKIT_DIR$\plugins\rtos\ThreadX\ThreadXCFPlugin.ewplugin</file>
        <loadFlag>0</loadFlag>
      </plugin>
      <plugin>
        <file>$TOOLKIT_DIR$\plugins\rtos\uCOS-II\uCOS-II-KA-CSpy.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\CodeCoverage\CodeCoverage.ENU.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\Orti\Orti.ENU.ewplugin</file>
        <loadFlag>0</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\Profiling\Profiling.ENU.ewplugin</file>
        <loadFlag>0</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\Stack\Stack.ENU.ewplugin</file>
        <loadFlag>0</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\SymList\SymList.ENU.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
    </debuggerPlugins>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>COLDFIRE</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>C-SPY</name>
      <archiveVersion>3</archiveVersion>
      <data>
        <version>1</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>CMandatory</name>
          <state>1</state>
        </option>
        <option>
          <name>CInput</name>
          <state>1</state>
        </option>
        <option>
          <name>DebuggerProcessorVariant</name>
          <state>0</state>
        </option>
        <option>
          <name>DebuggerNoDiv</name>
          <state>0</state>
        </option>
        <option>
          <name>DebuggerFPUnit</name>
          <state>0</state>
        </option>
        <option>
          <name>DebuggerMacMode</name>
          <state>0</state>
        </option>
        <option>
          <name>DebuggerPheripheral</name>
          <state>0</state>
        </option>
        <option>
          <name>CRunToEnable</name>
          <state>1</state>
        </option>
        <option>
          <name>CRunToName</name>
          <state>main</state>
        </option>
        <option>
          <name>CMacOverride</name>
          <state>0</state>
        </option>
        <option>
          <name>CMacFile</name>
          <state></state>
        </option>
        <option>
          <name>DynDriver</name>
          <state>SIMCF</state>
        </option>
        <option>
          <name>DDFOverride</name>
          <state>0</state>
        </option>
        <option>
          <name>DDFFile</name>
          <state></state>
        </option>
        <option>
          <name>DebugUseExtraOptions</name>
          <state>0</state>
        </option>
        <option>
          <name>DebugExtraOptions</name>
          <state></state>
        </option>
        <option>
          <name>FlashLoaders</name>
          <state></state>
        </option>
        <option>
          <name>UseFlashLoader</name>
          <state>0</state>
        </option>
        <option>
          <name>SuppressDownload</name>
          <state>0</state>
        </option>
        <option>
          <name>VerifyAll</name>
          <state>0</state>
        </option>
        <option>
          <name>OCImagesSuppressCheck1</name>
          <state>0</state>
        </option>
        <option>
          <name>OCImagesPath1</name>
          <state></state>
        </option>
        <option>
          <name>OCImagesSuppressCheck2</name>
          <state>0</state>
        </option>
        <option>
          <name>OCImagesPath2</name>
          <state></state>
        </option>
        <option>
          <name>OCImagesSuppressCheck3</name>
          <state>0</state>
        </option>
        <option>
          <name>OCImagesPath3</name>
          <state></state>
        </option>
      </data>
    </settings>
    <settings>
      <name>BDMCF</name>
      <archiveVersion>3</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>BdmMandatory</name>
          <state>1</state>
        </option>
        <option>
          <name>MemoryRanges</name>
          <state>1</state>
        </option>
        <option>
          <name>CommunicationPort</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>CommunicationType</name>
          <version>0</version>
          <state>0</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>JLINKCF</name>
      <archiveVersion>3</archiveVersion>
      <data>
        <version>1</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>JlinkMandatory</name>
          <state>1</state>
        </option>
        <option>
          <name>JLinkEnablePower</name>
          <state>0</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>SIMCF</name>
      <archiveVersion>3</archiveVersion>
      <data>
        <version>1</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>SimExceptions</name>
          <state>0</state>
        </option>
        <option>
          <name>SimMandatory</name>
          <state>1</state>
        </option>
        <option>
          <name>SimEnablePSP</name>
          <state>0</state>
        </option>
        <option>
          <name>SimPspOverrideConfig</name>
          <state>0</state>
        </option>
        <option>
          <name>SimPspConfigFile</name>
          <state>###Uninitialized###</state>
        </option>
      </data>
    </settings>
    <debuggerPlugins>
      <plugin>
        <file>$TOOLKIT_DIR$\plugins\rtos\embOS\embOSPlugin.ewplugin</file>
        <loadFlag>0</loadFlag>
      </plugin>
      <plugin>
        <file>$TOOLKIT_DIR$\plugins\rtos\MQX\MQXRtosPlugin.ewplugin</file>
        <loadFlag>0</loadFlag>
      </plugin>
      <plugin>
        <file>$TOOLKIT_DIR$\plugins\rtos\ThreadX\ThreadXCFPlugin.ewplugin</file>
        <loadFlag>0</loadFlag>
      </plugin>
      <plugin>
        <file>$TOOLKIT_DIR$\plugins\rtos\uCOS-II\uCOS-II-KA-CSpy.ewplugin</file>
        <loadFlag>0</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\CodeCoverage\CodeCoverage.ENU.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\Orti\Orti.ENU.ewplugin</file>
        <loadFlag>0</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\Profiling\Profiling.ENU.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\Stack\Stack.ENU.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\SymList\SymList.ENU.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
    </debuggerPlugins>
  </configuration>
</project>


