# IAR project Dnepr.ewp, settings and files
configuration Debug (COLDFIRE, debug)
  General.OGenDeviceSelectMenu: M5282 ColdFire - M5282
  General.GenCodeModel: 1
  General.GenStackSize: 0x200
  General.GenHeapSize: 0x80000
  General.GenDataModel: 1
  ICCCF.CCDefines: NO_inline; PB_BUFFER_ONLY; CONFIG_YAFFS_DIRECT; CONFIG_YAFFS_DEFINES_TYPES; CONFIG_YAFFSFS_PROVIDE_VALUES; CONFIG_YAFFS_SHORT_NAMES_IN_RAM; CONFIG_YAFFS_YAFFS2; CONFIG_YAFFS_PROVIDE_DEFS; DEBUG_TERMINAL; DEBUG_I2C
  ICCCF.CCIncludePath2: Sources; Sources/Profile/inc; Sources/Project_Headers; Sources/uCOS-II/inc; Sources/uCOS-II/src; Sources/uCOS_FS/API; Sources/uCOS_FS/CLIB; Sources/uCOS_FS/CONFIG/uCOS-II_Dnepr; Sources/uCOS_FS/DEVICE/NMNX_M25P128_uC_FS; Sources/uCOS_FS/DEVICE/ram; Sources/uCOS_FS/FSL/fat; Sources/uCOS_FS/LBL; Sources/uCOS_FS/OS; Sources/yaffs2; Sources/SlotEEPROM
  ICCCF.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ACF.AsmStdIncludePath: $TOOLKIT_DIR$\INC\
  prebuild: Sources\scripts\prebuild.bat $PROJ_DIR$
  postbuild: python.exe Sources\scripts\s19adopt.py -c DNEP0020 -i Debug\Exe\Dnepr.s19 -o Debug\Exe\Dnepr.mod.s19
  XLINK.XclFile: lnkM5282_dbg.xcl
  XLINK.XlinkStackSize: 1
  XLINK.XlinkHeapSize: 1
configuration Release (COLDFIRE)
  as the first configuration, except:
  ICCCF.CCDefines: NDEBUG; PB_BUFFER_ONLY; CONFIG_YAFFS_DIRECT; CONFIG_YAFFS_DEFINES_TYPES; CONFIG_YAFFSFS_PROVIDE_VALUES; CONFIG_YAFFS_SHORT_NAMES_IN_RAM; CONFIG_YAFFS_YAFFS2; CONFIG_YAFFS_PROVIDE_DEFS; DEBUG_TERMINAL; DEBUG_I2C
  ICCCF.CCDiagSuppress: Go005, Pe177
  postbuild: python.exe Sources\scripts\release_postbuild.py -v Sources\Profile\Generated\value.c -c DNEP0020 -i Release\Exe\Dnepr.s19
  XLINK.XclFile: lnkM5282_s19.xcl
  group (top)
    ./: cstartM5282.s68 vectortable.s68
    Sources/: low_level_init.c
  group Application
    Sources/: main.c prio.h T8_atomic_heap.c
  group Application/inc
    Sources/HAL/IC/inc/: Binary.h
    Sources/Project_Headers/: ctypes.h support_common.h T8_atomic_heap.h T8_Atomiccode.h
    Sources/Application/inc/: T8_Dnepr_Profile_params.h T8_Dnepr_ProfileStorage.h T8_Dnepr_TaskSynchronization.h
  group Application/src
    Sources/Application/src/: T8_Dnepr_Profile_params.c T8_Dnepr_ProfileStorage.c T8_Dnepr_TaskSynchronization.c
  group Application/Threads/inc
    Sources/Threads/inc/: threadCU.h threadDeviceController.h threadMeasure.h threadTerminal.h threadWatchdog.h
  group Application/Threads/src
    Sources/Threads/src/: threadCU.c threadDeviceController.c threadMeasure.c threadTerminal.c threadWatchdog.c
  group common_lib/inc
    Sources/common_lib/: cheksum.h crc.h medfilt.h memory.h T8_CircBuffer.h
  group common_lib/src
    Sources/common_lib/: cheksum.c crc.c medfilt.c memory.c T8_CircBuffer.c
  group ErrorManagement/inc
    Sources/ErrorManagement/: assert.h status_codes.h
  group ErrorManagement/src
    Sources/ErrorManagement/: assert.c
  group HAL
    Sources/: T8_Dnepr_SequencerSettings.c T8_Dnepr_SequencerSettings.h
  group HAL/BSP/inc
    Sources/HAL/BSP/inc/: T8_Dnepr_API.h T8_Dnepr_Backplane.h T8_Dnepr_BP_CurrentMeasure.h T8_Dnepr_BPEEPROM.h T8_Dnepr_EdgePort.h T8_Dnepr_Ethernet.h T8_Dnepr_Fans.h T8_Dnepr_filesystem.h T8_Dnepr_FPGA.h T8_Dnepr_GPIO.h T8_Dnepr_I2C.h T8_Dnepr_LED.h T8_Dnepr_QSPI.h T8_Dnepr_SDRAM.h T8_Dnepr_Select.h T8_Dnepr_SlotEEPROM.h T8_Dnepr_Uart_Profile.h
  group HAL/BSP/src
    Sources/HAL/BSP/src/: T8_Dnepr_API.c T8_Dnepr_Backplane.c T8_Dnepr_BP_CurrentMeasure.c T8_Dnepr_BPEEPROM.c T8_Dnepr_EdgePort.c T8_Dnepr_Ethernet.c T8_Dnepr_Fans.c T8_Dnepr_filesystem.c T8_Dnepr_FPGA.c T8_Dnepr_GPIO.c T8_Dnepr_I2C.c T8_Dnepr_isr.c T8_Dnepr_isr_wraps.s68 T8_Dnepr_LED.c T8_Dnepr_QSPI.c T8_Dnepr_SDRAM.c T8_Dnepr_Select.c T8_Dnepr_SlotEEPROM.c T8_Dnepr_UART_Profile.c T8_Dnepr_vectortable.s68
  group HAL/IC/inc
    Sources/HAL/IC/inc/: AD_AD7921.h at45db321d.h AT_AT24C512.h FRU_Registers.h I2C_interface.h IPMI.h LT_LTC4222.h MAX_DS28CM00.h MAX_MAX31785.h MV_88E6095.h NXP_PCA9551.h PMB_interface.h PMBus_Commands.h PSMI_Registers.h PSU_Driver.h SPI_Interface.h ST_M95M01.h T8_SFP.h TI_PCA9544A.h TI_TCA9539.h TI_TCA9555.h TI_TMP112.h TI_UCD9080.h
  group HAL/IC/src
    Sources/HAL/IC/src/: AD_AD7921.c at45db321d.c AT_AT24C512.c IPMI.c LT_LTC4222.c MAX_DS28CM00.c MAX_MAX31785.c MV_88E6095.c NXP_PCA9551.c PSU_Driver.c ST_M95M01.c T8_SFP.c TI_PCA9544A.c TI_TCA9539.c TI_TCA9555.c TI_TMP112.c TI_UCD9080.c
  group HAL/MCU/inc
    Sources/HAL/MCU/inc/: I2C_GenericDriver.h PMBus_GenericDriver.h SPI_GenericDriver.h T8_5282_cfm.h T8_5282_i2c.h T8_5282_interrupts.h T8_5282_MII.h T8_5282_spi.h T8_5282_timers.h T8_5282_uart.h T8_5282_wdt.h
  group HAL/MCU/src
    Sources/HAL/MCU/src/: I2C_GenericDriver.c PMBus_GenericDriver.c SPI_GenericDriver.c T8_5282_cfm.c T8_5282_i2c.c T8_5282_interrupts.c T8_5282_MII.c T8_5282_spi.c T8_5282_timers.c T8_5282_uart.c T8_5282_wdt.c
  group Profile/Generated
    Sources/Profile/Generated/: profile_def.h ta_and_pT_involver.c
  group Profile/inc
    Sources/Profile/inc/: extras.h pr_ch.h profile_processing.h sec_level.h sys.h
  group Profile/src
    Sources/Profile/src/: extras.c pr_ch.c profile_cover.c profile_processing.c sys.c
  group SlotEEPROM/inc
    Sources/SlotEEPROM/: SlotEEPROM_Optional.pb.h
  group SlotEEPROM/nanopb
    Sources/SlotEEPROM/: pb.h pb_decode.c pb_decode.h pb_encode.c pb_encode.h
  group SlotEEPROM/src
    Sources/SlotEEPROM/: SlotEEPROM_Optional.pb.c
  group Storage/inc
    Sources/Storage/inc/: eeprom_storage.h
  group Storage/src
    Sources/Storage/src/: eeprom_storage.c
  group uC/OS-II/inc
    Sources/uCOS-II/inc/: os_cfg.h OS_CFG_.H OS_CPU.H ucos_ii.h
  group uC/OS-II/src
    Sources/uCOS-II/src/: OS_CPU_A.S OS_CPU_C.C ucos_ii.c
  group YAFFS
    Sources/yaffs2/: yaffs_allocator.c yaffs_allocator.h yaffs_attribs.c yaffs_attribs.h yaffs_bitmap.c yaffs_bitmap.h yaffs_checkptrw.c yaffs_checkptrw.h yaffs_ecc.c yaffs_ecc.h yaffs_error.c yaffs_flashif.h yaffs_flashif2.h yaffs_getblockinfo.h yaffs_guts.c yaffs_guts.h yaffs_hweight.c yaffs_hweight.h yaffs_list.h yaffs_nameval.c yaffs_nameval.h yaffs_nand.c yaffs_nand.h yaffs_nandemul2k.h yaffs_osglue.h yaffs_packedtags1.c yaffs_packedtags1.h yaffs_packedtags2.c yaffs_packedtags2.h yaffs_qsort.c yaffs_summary.c yaffs_summary.h yaffs_tagscompat.c yaffs_tagscompat.h yaffs_tagsmarshall.c yaffs_tagsmarshall.h yaffs_trace.h yaffs_verify.c yaffs_verify.h yaffs_yaffs1.c yaffs_yaffs1.h yaffs_yaffs2.c yaffs_yaffs2.h yaffscfg.h yaffsfs.c yaffsfs.h ydirectenv.h
